# Repository fake-rick/caw-drive

File README.md:

# 🐦 CawDrive - 无刷电机驱动器

---

中文 | [English](https://github.com/fake-rick/caw-drive/blob/master/Docs/README_EN.md)

# 🚀 简介

- 支持 24 电压输入

- 外部编码器接口支持：霍尔，SPI，I2C

- 主控芯片：STM32F446，电机驱动芯片为 DRV8323RSRGZR

- 板载磁编码器：MT6835GT-STD（21bit）

- 支持电机线圈温度采样和驱动器温度采样

- 支持双路低端相电流采样

- 支持母线电压采样

- 支持CAN和USART通讯

- 支持SWD下载和调试

- 支持 6xPWM 和 3xPWM 的控制

# 🗂️ 目录

* Firmware：旧版代码（弃用）

* Firmware_F446：FOC控制的实际控制代码以及STM32CubeMX配置

* PCB：FOC驱动器原理图、PCB以及生成的Gerber文件

# 📦 固件编译（开发中）

## 配置caw-embedded库

当前固件编译依赖caw-embedded项目: https://github.com/fake-rick/caw-embedded

依赖添加方式1：

可以直接将caw-embedded项目克隆到caw-drive/Firmware目录下:

```bash
cd caw-drive/Firmware
git clone git@github.com:fake-rick/caw-embedded.git caw_embedded
```

依赖添加方式2：

将caw-embedded项目克隆后建立链接（Linux），假设将caw-embedded放在与caw-drive同级目录下:

```bash
git clone git@github.com:fake-rick/caw-embedded.git
cd caw-drive/Firmware
ln -s ../../caw-embedded caw_embedded
```

# 🛠 VSCode配置

安装并配置stm32-for-vscode插件

# 👻 图片展示

# 🖥️ 上位机

# 📝 参考资料

https://github.com/bgkatz/3phase_integrated

## KiCad design PCB/CawDrive.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C11, C12, C13, C14, C17, C18: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C9: 2.2uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C19: 0.1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CN2: WAFER-SH1.0-6PWB; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
CN3: WAFER-SH1.0-4PWB; CONN-SMD_4P-P1.00_WAFER-SH1.0-4PWB
D1: MCU_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D2: DRV_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D4: PWR_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D6: ENCODER_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via; not fitted
H8, H9: MountingHole_Pad; POWER_PAD; not fitted
L1: 39nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R1, R20: 10k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2, R3, R5, R6, R10: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R24: 0Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R9, R11, R15: 510Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8: 75k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12: 3k 0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R21: 10k NTC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23, R25: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R26: 120Ω 1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Pad_D1.0mm
TV1: SMAJ36CA/TR13; SMAJ36CA_TR13_SMA(DO-214AC); JLC Part Number C87270
U1: TJA1051T/3/1J; TJA1051T31J_SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL
U5, U6, U10, U11, U12: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
U8: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U9: MT6835GT-STD
X1: CSTNE16M0V530000R0; Crystal_SMD3213-3P; JLC Part Number C341521

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C17.2, C18.2, CN2.4, D1.2 (A), D2.2 (A), D4.2 (A), D6.2 (A), L1.1, R1.2, R2.2, R5.2, R6.2, R10.1, R20.2, U1.5 (VIO), U8.1 (VBAT), U8.19 (VDD), U8.32 (VDD), U8.48 (VDD), U8.64 (VDD), U9.9 (VDD), U12.1; also elsewhere on the board
+3.3VA: C11.1, L1.2, U8.13 (VDDA)
+5V: C13.1, U1.3 (VCC), U11.1; also elsewhere on the board
+36V: H9.1, R8.2, TV1.1 (K); also elsewhere on the board
/ADC1_IN0: U8.14 (PA0); also elsewhere on the board
/ADC1_IN10: C19.1, R8.1, R12.2, U8.8 (PC0)
/ADC2_IN1: U8.15 (PA1); also elsewhere on the board
/ADC2_IN9: C1.2, R1.1, U6.1, U8.27 (PB1)
/ADC3_IN2: C12.2, R20.1, R21.2, U8.16 (PA2)
/CAN_N: R26.1, U1.6 (CANL), U5.1
/CAN_P: R26.2, U1.7 (CANH), U5.2
/CAN_RX: U1.4 (RXD), U8.61 (PB8)
/CAN_STB: U1.8 (S), U8.57 (PB5)
/CAN_TX: U1.1 (TXD), U8.62 (PB9)
/DRV_CAL: U8.38 (PC7); also elsewhere on the board
/DRV_ENABLE: U8.39 (PC8); also elsewhere on the board
/DRV_FAULT: U8.40 (PC9); also elsewhere on the board
/DRV_SPI_NSS: U8.54 (PD2); also elsewhere on the board
/DRV_STA: R11.2, U8.10 (PC2)
/ENCODER_CAL_EN: U8.50 (PA15), U9.4 (CAL_EN)
/ENCODER_SPI_NSS: U8.55 (PB3), U9.8 (CSN)
/ENCODER_STA: R15.2, U8.9 (PC1)
/HSE_IN: U8.5 (PH0), X1.1 (OSC1)
/HSE_OUT: U8.6 (PH1), X1.3 (OSC2)
/I2C1_SCL: R5.1, U8.58 (PB6), U10.2
/I2C1_SDA: R6.1, U8.59 (PB7), U10.1
/MCU_STA: R9.2, U8.11 (PC3)
/RESET: C14.1, R10.2, U8.7 (NRST)
/SPI1_MISO: CN3.2, U8.22 (PA6)
/SPI1_MOSI: CN3.3, U8.23 (PA7)
/SPI1_NSS: CN3.4, U8.26 (PB0)
/SPI1_SCK: CN3.1, U8.21 (PA5)
/SPI3_MISO: U8.52 (PC11), U9.5 (MISO); also elsewhere on the board
/SPI3_MOSI: U8.53 (PC12), U9.6 (MOSI); also elsewhere on the board
/SPI3_SCK: U8.51 (PC10), U9.7 (SCK); also elsewhere on the board
/SWCLK: CN2.1, R3.2, U8.49 (PA14)
/SWDIO: CN2.2, R2.1, U8.46 (PA13)
/TIM1_BKIN: U8.33 (PB12), U8.37 (PC6)
/TIM1_CH1: TP4.1, U8.41 (PA8); also elsewhere on the board
/TIM1_CH1N: TP1.1, U8.34 (PB13); also elsewhere on the board
/TIM1_CH2: TP5.1, U8.42 (PA9); also elsewhere on the board
/TIM1_CH2N: TP2.1, U8.35 (PB14); also elsewhere on the board
/TIM1_CH3: TP6.1, U8.43 (PA10); also elsewhere on the board
/TIM1_CH3N: TP3.1, U8.36 (PB15); also elsewhere on the board
/USART3_RX: CN2.6, U8.25 (PC5)
/USART3_TX: CN2.5, U8.29 (PB10)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C9.1, C11.2, C12.1, C13.2, C14.2, C17.1, C18.1, C19.2, CN2.3, R3.1, R4.2, R7.2, R12.1, R21.1, R23.1, R24.2, R25.2, U1.2 (GND), U6.2, U8.18 (VSS), U8.31 (VSS), U8.47 (VSS), U8.63 (VSS), U9.11 (TEST), U9.12 (VSS), U9.13 (TEST_EN), U11.2, U12.2, X1.2 (GND); also elsewhere on the board
GND1: H8.1, R4.1, TV1.2 (A); also elsewhere on the board
unnamed: D1.1 (K), R9.1
unnamed: D2.1 (K), R11.1
unnamed: D4.1 (K), R7.1
unnamed: D6.1 (K), R15.1
unnamed: R23.2, U8.60 (BOOT0)
unnamed: R25.1, U8.28 (PB2)
unnamed: TP7.1, U8.2 (PC13)
unnamed: C9.2, U8.30 (VCAP_1)
unnamed: R24.1, U8.12 (VSSA)

Notes on the sheet:
母线电压
电机温度采样
驱动器温度采样
36v电源输入
CAN
+3.3VA模拟电源滤波
位置传感器
电机驱动A
外部高速晶振
状态指示灯

Parts:
C7, C31, C32: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10: 0.1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C15, C33: 0.1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C34, C35: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C21, C22, C23, C24, C25, C26, C29, C36, C37, C38: 10uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C27: 47nF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C28: 1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30: 0.1uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D3: D_Schottky_Small; D_SOD-123
H5, H6, H7: MountingHole_Pad; POWER_PAD; not fitted
L2: 22uH_±20%_1.4A; LQH5BPB220MT0L_IND-SMD_L5.0-W5.0
Q7, Q8, Q9, Q10, Q11, Q12: TPH3R704PL; TPHR8504PL,L1Q
R13: 54.9k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R14: 10k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16, R17: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R18, R19: 5mΩ 1%; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder
U2: TLV76733DRVR; TLV76733DRVR_SON65P200X200X80-7N
U7: DRV8323RSRGZR; DRV8323RS_QFN-48-EP(7x7); JLC Part Number C545497

Connections:
+3.3V: C32.1, C34.1, C35.1, R16.1, R17.1, U2.1 (OUT), U2.2 (SNS), U7.26 (VREF); also elsewhere on the board
+5V: C7.1, C16.1, L2.2, R13.1, U2.4 (EN), U2.6 (IN); also elsewhere on the board
+36V: C10.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C33.1, C36.1, C37.1, C38.1, Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q7.9 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q11.9 (D), U7.6 (VM), U7.7 (VDRAIN), U7.47 (VIN); also elsewhere on the board
/ADC1_IN0: U7.25 (SOA); also elsewhere on the board
/ADC2_IN1: U7.24 (SOB); also elsewhere on the board
/DRV8323RSRGZR/CB: C15.1, U7.44 (CB)
/DRV8323RSRGZR/FB: R13.2, R14.1, U7.1 (FB)
/DRV8323RSRGZR/GHA: Q7.4 (G), U7.8 (GHA)
/DRV8323RSRGZR/GHB: Q9.4 (G), U7.17 (GHB)
/DRV8323RSRGZR/GHC: Q11.4 (G), U7.18 (GHC)
/DRV8323RSRGZR/GLA: Q8.4 (G), U7.10 (GLA)
/DRV8323RSRGZR/GLB: Q10.4 (G), U7.15 (GLB)
/DRV8323RSRGZR/GLC: Q12.4 (G), U7.20 (GLC)
/DRV8323RSRGZR/PHASA: H5.1, Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D), U7.9 (SHA)
/DRV8323RSRGZR/PHASB: H6.1, Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), U7.16 (SHB)
/DRV8323RSRGZR/PHASC: H7.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), Q12.9 (D), U7.19 (SHC)
/DRV8323RSRGZR/SPA: Q8.1 (S), Q8.2 (S), Q8.3 (S), R18.1, U7.11 (SPA)
/DRV8323RSRGZR/SPB: Q10.1 (S), Q10.2 (S), Q10.3 (S), R19.1, U7.14 (SPB)
/DRV8323RSRGZR/SW: C15.2, D3.1 (K), L2.1, U7.45 (SW)
/DRV_CAL: U7.34 (CAL); also elsewhere on the board
/DRV_ENABLE: U7.33 (ENABLE); also elsewhere on the board
/DRV_FAULT: R17.2, U7.28 (nFAULT); also elsewhere on the board
/DRV_SPI_NSS: U7.32 (nSCS); also elsewhere on the board
/SPI3_MISO: R16.2, U7.29 (SDO); also elsewhere on the board
/SPI3_MOSI: U7.30 (SDI); also elsewhere on the board
/SPI3_SCK: U7.31 (SCLK); also elsewhere on the board
/TIM1_CH1: U7.37 (INHA); also elsewhere on the board
/TIM1_CH1N: U7.38 (INLA); also elsewhere on the board
/TIM1_CH2: U7.39 (INHB); also elsewhere on the board
/TIM1_CH2N: U7.40 (INLB); also elsewhere on the board
/TIM1_CH3: U7.41 (INHC); also elsewhere on the board
/TIM1_CH3N: U7.42 (INLC); also elsewhere on the board
GND: C7.2, C16.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, D3.2 (A), R14.2, U2.3 (GND), U2.5 (GND), U2.7 (NC), U7.2 (PGND), U7.27 (DGND), U7.35 (AGND), U7.43 (BGND), U7.49 (EP); also elsewhere on the board
GND1: C10.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C29.2, C36.2, C37.2, C38.2, Q12.1 (S), Q12.2 (S), Q12.3 (S), R18.2, R19.2, U7.12 (SNA), U7.13 (SNB), U7.21 (SPC), U7.22 (SNC); also elsewhere on the board
unnamed: C27.2, U7.4 (CPH)
unnamed: C27.1, U7.3 (CPL)
unnamed: C31.1, U7.36 (DVDD)
unnamed: C28.2, U7.5 (VCP)

Notes on the sheet:
滤波电容
降压电路(3.3V)
电机接口
降压电路（5V）
MOS

Board: 4 copper layers, 50.0 x 42.0 mm, 107 parts (4 on the bottom side), 75 nets.

Other parts of the board:
kibuzzard-67F13BB6: G***; kibuzzard-67F13BB6
kibuzzard-67F4292F: G***; kibuzzard-67F4292F

## KiCad design PCB/HallConnector/HallConnector.kicad_pcb

Parts:
C1, C2, C3: 10pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
CN3: WAFER-SH1.0-4PWB; CONN-SMD_4P-P1.00_WAFER-SH1.0-4PWB
D4: STA_LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
R1, R2, R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6: 1.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 510Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB

Connections:
+3.3V: D4.2 (A), R1.1, R2.1, R3.1, U1.2
+5V: J1.1, U2.2
/SPI1_MISO: C1.1, CN3.3, R1.2, R6.1
/SPI1_MOSI: C2.1, CN3.2, R2.2, R5.1
/SPI1_NSS: C3.1, CN3.1, R3.2, R4.1
/SPI1_SCK: CN3.4, R7.2
GND: C1.2, C2.2, C3.2, J1.2, U1.1, U2.1
unnamed: D4.1 (K), R7.1
unnamed: J1.3, R6.2
unnamed: J1.4, R5.2
unnamed: J1.5, R4.2

Board: 2 copper layers, 21.5 x 19.0 mm, 21 parts (6 on the bottom side), 11 nets.

Other parts of the board:
kibuzzard-67FE44A7: G***; kibuzzard-67FE44A7
kibuzzard-67FE44AF: G***; kibuzzard-67FE44AF
kibuzzard-67FE44BA: G***; kibuzzard-67FE44BA
kibuzzard-67FE447B: G***; kibuzzard-67FE447B
kibuzzard-67FE4499: G***; kibuzzard-67FE4499
kibuzzard-67FE4510: G***; kibuzzard-67FE4510

## KiCad design CawDrive.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C8, C9, C11, C12, C14, C17: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CN1, CN2: WAFER-SH1.0-6PWB; CONN-SMD_6P-P1.00_XUNPU_WAFER-SH1.0-6PWB
D1: MCU_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D2: DRV_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
D4: PWR_STA_LED; LED_0402_1005Metric_Pad0.77x0.64mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad_Via; not fitted
H8, H9: MountingHole_Pad; POWER_PAD; not fitted
L1: 39nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder
R1, R2, R10, R20, R21: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4, R15: 0Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R9, R11: 510Ω; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8: 120Ω 1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
TV1: SMAJ36CA/TR13; SMAJ36CA_TR13_SMA(DO-214AC); JLC Part Number C87270
U1: AS5047P-ATSM
U3: TCAN1044DRBRQ1; TCAN1044DRBRQ1_DFN-8_L3.0-W3.0-P0.65-TL-EP2.4
U4: STM32G474RETx; LQFP-64_10x10mm_P0.5mm
U5, U6: WAFER-SH1.0-2PWB; CONN-SMD_2P-P1.00_XUNPU_WAFER-SH1.0-2PWB
X1: CSTNE16M0V530000R0; Crystal_SMD3213-3P; JLC Part Number C341521

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C9.2, C17.2, CN1.6, CN2.4, D1.2 (A), D2.2 (A), D4.2 (A), L1.1, R1.2, R2.1, R10.1, R20.2, U1.11 (VDD), U1.12 (VDD3V3), U3.5 (NC/VIO), U4.1 (VBAT), U4.16 (VDD), U4.32 (VDD), U4.48 (VDD), U4.64 (VDD); also elsewhere on the board
+3.3VA: C8.1, C11.1, L1.2, U4.28 (VREF+), U4.29 (VDDA)
+5V: C12.2, U3.3 (VCC); also elsewhere on the board
+36V: H9.1, TV1.1 (K); also elsewhere on the board
/ADC1_IN1: U4.12 (PA0); also elsewhere on the board
/ADC1_IN2: U4.13 (PA1); also elsewhere on the board
/ADC1_IN3: C1.2, R1.1, U4.14 (PA2), U6.1
/AS5047P_NSS: U1.1 (CSn), U4.46 (PA12)
/CAN_N: R8.1, U3.6 (CANL), U5.1
/CAN_P: R8.2, U3.7 (CANH), U5.2
/DRV_CAL: U4.39 (PC7); also elsewhere on the board
/DRV_ENABLE: U4.40 (PC8); also elsewhere on the board
/DRV_FAULT: U4.41 (PC9); also elsewhere on the board
/DRV_SPI_NSS: U4.51 (PA15); also elsewhere on the board
/DRV_STA: R11.2, U4.25 (PB1)
/FDCAN_RX: U3.4 (RXD), U4.56 (PB3), U4.58 (PB5)
/FDCAN_STB: U3.8 (STB), U4.55 (PD2)
/FDCAN_TX: U3.1 (TXD), U4.57 (PB4), U4.59 (PB6)
/HSE_IN: U4.5 (PF0), X1.1 (OSC1)
/HSE_OUT: U4.6 (PF1), X1.3 (OSC2)
/MCU_STA: R9.2, U4.26 (PB2)
/RESET: C14.1, R10.2, U4.7 (PG10)
/SPI1_MISO: CN1.3, R2.2, U4.20 (PA6)
/SPI1_MOSI: CN1.2, U4.21 (PA7)
/SPI1_NSS: CN1.1, U4.18 (PA4)
/SPI1_SCK: CN1.4, U4.19 (PA5)
/SPI3_MISO: U1.3 (MISO), U4.53 (PC11); also elsewhere on the board
/SPI3_MOSI: U1.4 (MOSI), U4.54 (PC12); also elsewhere on the board
/SPI3_SCK: U1.2 (CLK), U4.52 (PC10); also elsewhere on the board
/SWCLK: CN2.1, R21.1, U4.50 (PA14)
/SWDIO: CN2.2, R20.1, U4.49 (PA13)
/TIM1_BKIN: U4.34 (PB12), U4.38 (PC6)
/TIM1_CH1: U4.42 (PA8); also elsewhere on the board
/TIM1_CH1N: U4.35 (PB13); also elsewhere on the board
/TIM1_CH2: U4.43 (PA9); also elsewhere on the board
/TIM1_CH2N: U4.36 (PB14); also elsewhere on the board
/TIM1_CH3: U4.44 (PA10); also elsewhere on the board
/TIM1_CH3N: U4.37 (PB15); also elsewhere on the board
/USART1_RX: CN2.6, U4.23 (PC5)
/USART1_TX: CN2.5, U4.22 (PC4)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.1, C11.2, C12.1, C14.2, C17.1, CN1.5, CN2.3, R4.2, R7.2, R12.2, R15.2, R21.2, U1.5 (Test), U1.13 (GND), U3.2 (GND), U3.9 (EP), U4.15 (VSS), U4.31 (VSS), U4.47 (VSS), U4.63 (VSS), U6.2, X1.2 (GND); also elsewhere on the board
GND1: H8.1, R4.1, TV1.2 (A); also elsewhere on the board
unnamed: D1.1 (K), R9.1
unnamed: D2.1 (K), R11.1
unnamed: D4.1 (K), R7.1
unnamed: R12.1, U4.61 (PB8)
unnamed: R15.1, U4.27 (VSSA)

Notes on the sheet:
温度采样
36v电源输入
CAN
+3.3VA模拟电源滤波
位置传感器
电机驱动A
外部高速晶振
状态指示灯

Parts:
C7, C31, C32: 1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C10: 0.1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C15, C33: 0.1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C16, C34, C35: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C21, C22, C23, C24, C25, C26, C29: 10uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C27: 47nF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C28: 1uF/50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30: 0.1uF/50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D3: D_Schottky_Small; D_SOD-123
H5, H6, H7: MountingHole_Pad; POWER_PAD; not fitted
L2: 22uH_±20%_1.4A; LQH5BPB220MT0L_IND-SMD_L5.0-W5.0
Q7, Q8, Q9, Q10, Q11, Q12: TPH3R704PL; TPHR8504PL,L1Q
R13: 54.9k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R14: 10k ±0.1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16, R17: 10k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R18, R19: 1mΩ 1%; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder
U2: TLV76733DRVR; TLV76733DRVR_SON65P200X200X80-7N
U7: DRV8323RSRGZR; DRV8323RS_QFN-48-EP(7x7); JLC Part Number C545497

Connections:
+3.3V: C32.1, C34.1, C35.1, R16.1, R17.1, U2.1 (OUT), U2.2 (SNS), U7.26 (VREF); also elsewhere on the board
+5V: C7.1, C16.1, L2.2, R13.1, U2.4 (EN), U2.6 (IN); also elsewhere on the board
+36V: C10.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C33.1, Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q7.9 (D), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q11.9 (D), U7.6 (VM), U7.7 (VDRAIN), U7.47 (VIN); also elsewhere on the board
/ADC1_IN1: U7.25 (SOA); also elsewhere on the board
/ADC1_IN2: U7.24 (SOB); also elsewhere on the board
/DRV8323RSRGZR/CB: C15.1, U7.44 (CB)
/DRV8323RSRGZR/FB: R13.2, R14.1, U7.1 (FB)
/DRV8323RSRGZR/GHA: Q7.4 (G), U7.8 (GHA)
/DRV8323RSRGZR/GHB: Q9.4 (G), U7.17 (GHB)
/DRV8323RSRGZR/GHC: Q11.4 (G), U7.18 (GHC)
/DRV8323RSRGZR/GLA: Q8.4 (G), U7.10 (GLA)
/DRV8323RSRGZR/GLB: Q10.4 (G), U7.15 (GLB)
/DRV8323RSRGZR/GLC: Q12.4 (G), U7.20 (GLC)
/DRV8323RSRGZR/PHASA: H5.1, Q7.1 (S), Q7.2 (S), Q7.3 (S), Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D), U7.9 (SHA)
/DRV8323RSRGZR/PHASB: H6.1, Q9.1 (S), Q9.2 (S), Q9.3 (S), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), U7.16 (SHB)
/DRV8323RSRGZR/PHASC: H7.1, Q11.1 (S), Q11.2 (S), Q11.3 (S), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), Q12.9 (D), U7.19 (SHC)
/DRV8323RSRGZR/SPA: Q8.1 (S), Q8.2 (S), Q8.3 (S), R18.1, U7.11 (SPA)
/DRV8323RSRGZR/SPB: Q10.1 (S), Q10.2 (S), Q10.3 (S), R19.1, U7.14 (SPB)
/DRV8323RSRGZR/SW: C15.2, D3.1 (K), L2.1, U7.45 (SW)
/DRV_CAL: U7.34 (CAL); also elsewhere on the board
/DRV_ENABLE: U7.33 (ENABLE); also elsewhere on the board
/DRV_FAULT: R17.2, U7.28 (nFAULT); also elsewhere on the board
/DRV_SPI_NSS: U7.32 (nSCS); also elsewhere on the board
/SPI3_MISO: R16.2, U7.29 (SDO); also elsewhere on the board
/SPI3_MOSI: U7.30 (SDI); also elsewhere on the board
/SPI3_SCK: U7.31 (SCLK); also elsewhere on the board
/TIM1_CH1: U7.37 (INHA); also elsewhere on the board
/TIM1_CH1N: U7.38 (INLA); also elsewhere on the board
/TIM1_CH2: U7.39 (INHB); also elsewhere on the board
/TIM1_CH2N: U7.40 (INLB); also elsewhere on the board
/TIM1_CH3: U7.41 (INHC); also elsewhere on the board
/TIM1_CH3N: U7.42 (INLC); also elsewhere on the board
GND: C7.2, C16.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, D3.2 (A), R14.2, U2.3 (GND), U2.5 (GND), U2.7 (NC), U7.2 (PGND), U7.27 (DGND), U7.35 (AGND), U7.43 (BGND), U7.49 (EP); also elsewhere on the board
GND1: C10.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C29.2, Q12.1 (S), Q12.2 (S), Q12.3 (S), R18.2, R19.2, U7.12 (SNA), U7.13 (SNB), U7.21 (SPC), U7.22 (SNC); also elsewhere on the board
unnamed: C27.2, U7.4 (CPH)
unnamed: C27.1, U7.3 (CPL)
unnamed: C31.1, U7.36 (DVDD)
unnamed: C28.2, U7.5 (VCP)

Notes on the sheet:
滤波电容
降压电路(3.3V)
电机接口
降压电路（5V）
MOS

Board: 4 copper layers, 42.0 x 42.0 mm, 84 parts (2 on the bottom side), 65 nets.

Other parts of the board:
kibuzzard-66ADBF8B: G***; kibuzzard-66ADBF8B
kibuzzard-66ADCBBA: G***; kibuzzard-66ADCBBA

## Commit log

2023-08-26 🎉初始提交
2023-09-17 参考MIT驱动器进行改版
2023-09-19 将线性稳压芯片和CAN芯片替换成TI的相关型号
2023-09-19 拼板制作
2023-10-02 优化底层丝印
2023-10-03 优化布线
2023-10-04 更新README
2023-10-04 Create LICENSE
2023-10-04 添加Gerber文件
2023-10-04 生成BOM物料表
2023-10-04 更新BOM
2024-08-23 升级主控STM32G474，增加AS5047P编码器，支持NTC温度采样
2024-09-25 合并固件代码
2024-09-27 支持AS5047P传感器读取位置信息
2024-09-28 完善编码器功能，将编码器对象添加到Motor
2024-09-30 完成闭环速度控制🥳
2024-10-01 完成闭环位置控制
2024-11-14 完成电流闭环控制
2025-02-12 新增电机初始化功能，支持参数存储Flash
2025-02-15 优化串口数据传输
2025-02-15 新增参数存储功能
2025-02-23 优化通讯和事件处理
2025-04-05 升级V2版，支持3路电流采样以及霍尔传感器
2025-04-05 增加测试点PC13引脚
2025-04-07 更新文档
2025-04-07 Create CNAME
2025-04-07 删除caw_embedded链接
2025-04-07 优化布线，生成Gerber文件
2025-04-08 增加HALL传感器接口板
2025-04-10 更新电阻精度，重新生成BOM
2025-04-13 更新采样电阻精度，重新生成BOM
2025-04-14 测试PWM波形，完成状态LED控制
2025-04-15 修复霍尔接口板线序问题，完成串口测试
2025-04-15 完成低端电流采样触发时间测试
2025-04-16 完成三相电流采样与母线电压采样
2025-04-17 完成驱动器温度采样
2025-04-18 测试霍尔编码器数据读取，完善README
2025-04-20 优化电流采样布线
2025-04-21 优化ADC采样布线
2025-04-21 优化走线
2025-04-22 更新Gerber
2025-04-23 PCB走线优化
2025-04-23 文档更新
2025-05-07 优化PCB
